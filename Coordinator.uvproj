# Keil uVision project Coordinator.uvproj, settings and files
target Coordinator (ARM-ADS)
  device: LM3S9B96 Luminary Micro
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LM3S_uCOS2
  c flags: Optim=1
  c define: LRWPAN_DEBUG  LRWPAN_COORDINATOR aExtendedAddress
  c include: .\stack;.\Luminary;.\User;.\Middleware;.\Target;.\uCOS-II\Ports;.\uCOS-II\Source;.\Library\drivers
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --entry Reset_Handler
  group Comment
    ./Comment/: Errata.txt LM3S_uCOS2.map
  group LM3S DriverLib
    ./Library/grlib/rvmdk/: grlib.lib
    E:/work_sofeware/keil/ARM/RV31/LIB/Luminary/: driverlib.lib
  group Middleware
    ./Middleware/: evboard.c evbRadio.c halNeighbor.c halStack.c
  group Target
    ./Target/: Startup.s Target.c Target.h
  group Stack
    ./stack/: aps.c console.c debug.c mac.c memalloc.c neighbor.c nwk.c pcbind.c phy.c staticbind.c zep.c
  group uC/OS-II Source
    ./uCOS-II/Source/: OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C uCOS_II.H OS_CORE.C
  group uC/OS-II Ports
    ./uCOS-II/Ports/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group LCD
    ./Library/drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c
  group User
    ./User/: Main.c
